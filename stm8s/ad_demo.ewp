# IAR project ad_demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\stm8_project\p2\inc; D:\stm8_project\p2; D:\stm8_project\p2\myfunctiion; D:\stm8_project\p2
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group StdPeriph_Driver
    src/: stm8s_adc1.c stm8s_gpio.c stm8s_tim2.c
  group user
    myfunctiion/: adc.c adc.h delay.c delay.h led.c led.h
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
